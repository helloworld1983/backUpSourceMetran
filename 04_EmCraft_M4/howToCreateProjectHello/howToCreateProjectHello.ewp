# IAR project howToCreateProjectHello.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMX8MQ6_M4 NXP MIMX8MQ6_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MIMX8MQ6DVAJZ; DEBUG
  ICCARM.CCIncludePath2: board; drivers; source; startup; utilities; CMSIS/include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: howToCreateProjectHello.bin
  ILINK.IlinkOutputFile: howToCreateProjectHello.out
  ILINK.IlinkIcfFile: MIMX8MQ6xxxJZ_cm4_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    board/: board.c board.h clock_config.c clock_config.h fsl_iomuxc.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/include/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h tz_context.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_device_registers.h fsl_ecspi.c fsl_ecspi.h fsl_rdc.c fsl_rdc.h fsl_uart.c fsl_uart.h
  group source
    source/: hello_world.c
  group startup
    startup/: MIMX8MQ6_cm4.h MIMX8MQ6_cm4_features.h startup_MIMX8MQ6_cm4.s system_MIMX8MQ6_cm4.c system_MIMX8MQ6_cm4.h
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
